# Keil uVision project sdk.uvprojx, settings and files
target sdk (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sdk
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sources
    ./: main.c gpio.c leds.c ext_in.c i2c.c ssd1306.c fonts.c
  group includes
    ./: gpio.h leds.h ext_in.h i2c.h ssd1306.h fonts.h
  group system
    ./: delay.h delay.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.1, Device:Startup 1.0.0
